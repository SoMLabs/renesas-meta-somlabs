UBOOT_URL = "git://github.com/SoMLabs/somlabs-renesas-u-boot-cip.git"
BRANCH = "v2021.10/rz-somlabs"

SRCREV = "c82ce3f64ff5ac67881dd7eac6fd9e03065c4833"
